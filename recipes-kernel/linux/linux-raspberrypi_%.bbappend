FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " file://w1-gpio.cfg "

