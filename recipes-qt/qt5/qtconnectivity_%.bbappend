EXTRA_QMAKEVARS_PRE += " CONFIG+=config_bluez "
